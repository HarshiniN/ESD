	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R1,=DST
	LDR R2,[R0],#4
	LDR R3,[R0]
UP TEQ R3,#0
	BEQ DOWN
	BL AD
	ADD R11,R9
	ADD R12,R6
	B UP
DOWN
	STR R11,[R1],#4
	STR R12,[R1]
STOP B STOP

AD
	MOV R8,#0
	MOV R10,#8
	MOV R9,#0
	MOV R6,#0
	MOV R7,#0
	
ONE MOV R4,R2
	LSR R4,R8
	AND R4,R4,#0X0F
	MOV R5,R11
	LSR R5,R8
	AND R5,R5,#0X0F
	ADD R5,R6
	ADD R6,R4,R5
	CMP R6,#09
	BLS SKIP
	ADD R6,#06
SKIP
	AND R7,R6,#0X0F
	LSR R6,#04
	ORR R9,R7
	ROR R9,#04
	ADD R8,#04
	SUB R10,#01
	TEQ R10,#0
	BNE ONE
	BX LR

SRC DCD 0X5
	AREA DATASEG,DATA,READWRITE

DST DCD 0
	END