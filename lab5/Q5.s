	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N
	LDR R1,=DST
	MOV R2,#01
	MOV R3,#01
	STR R2,[R1],#04
	STR R3,[R1],#04
	BL RECUR
STOP B STOP

RECUR
	LDR R2,[R1,#-4]
	LDR R3,[R1,#-8]
	ADD R2,R3
	CMP R2,R0
	BHI EXIT
	STR R2,[R1],#4
	PUSH {R14}
	BL RECUR
EXIT POP {R14}
	BX LR
N EQU 9

	AREA DATASEG,DATA,READWRITE

DST DCD 0
	END