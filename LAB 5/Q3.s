	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	
	MOV R3,#10
	LDR R0,=SRC1
	LDR R1,=SRC2
	MOV R6,#0
	LDR R5,[R1]
	LDR R2,=DST
UP
	LDR R4,[R0],#4
	TEQ R4,R5
	BEQ DOWN
	SUB R3,#1
	TEQ R3,#0
	BNE UP
	B D
DOWN MOV R6,#1
D   TEQ R6,#1
	STRBEQ R6,[R2]

STOP B STOP
SRC1 DCD 0XA,0XB,0XC,0XD,0XE,0XF,0X1,0X2,0X3,0X4
SRC2 DCD 0X12
	AREA DATASEG,DATA,READWRITE
DST DCB 0
	END