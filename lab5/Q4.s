	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R1,=DST
	LDR R2,[R0]
	MOV R3,#1
	BL RECUR
	STR R3,[R1]
STOP B STOP
RECUR
	MUL R3,R2
	SUB R2,#01
	TEQ R2,#01
	BEQ EXIT
	PUSH {R14}
	BL RECUR
EXIT POP {R14}
    BX LR

SRC DCD 0X6
	AREA DATASEG,DATA,READWRITE

DST DCD 0
	END