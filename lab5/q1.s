	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R1,=DST
	LDR R2,[R0],#4
	LDR R3,[R0]
	ADD R4,R2
	ADD R5,R3
UP 
	CMP R4,R5
	BEQ EXIT
	BHI DOWN
	ADD R4,R2
	B UP
DOWN ADD R5,R3
	B UP
EXIT STR R4,[R1]
STOP B STOP
SRC DCD 0x15,0x10
	AREA DATASEG,DATA,READWRITE

DST DCD 0
	END