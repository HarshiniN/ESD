	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R1,=DST
	
	MOV R6,#10
	LDR R3,[R0]
UP	LDR R0,=SRC
	MOV R4,#0
	MOV R5,#10
	BL MIN
	STR R3,[R1],#4
	SUB R6,#1
	TEQ R6,#0
	BNE UP
	
STOP B STOP
MIN
U	LDR R2,[R0,R4]!
	CMP R2,R3
	BHS DOWN
	LDR R3,[R0]
	ADD R4,#4
	SUB R5,#1
	TEQ R5,#0
	
	BNE U
	
	BX LR

SRC DCD 0XF,0XE,0XD,0XC,0XB,0XA,0X1,0X2,0X3,0X4
	AREA DATASEG,DATA,READWRITE

DST DCD 0
	END