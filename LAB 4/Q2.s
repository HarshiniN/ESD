	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R4,#8
	LDR R0,=SRC
	LDR R1,=DST
UP
	LDRB R2,[R0],#1
	CMP R2,#0x39
	BLS DOWN
	SUB R2,#0x7
DOWN
	SUB R2,#0x30
	
	ORR R3,R2
	ROR R3,#4
	SUB R4,#1
	TEQ R4,#0
	BNE UP
	STR R3,[R1]
STOP B STOP
SRC DCB 0x41,0x42,0x43,0x44,0x45,0x46,0x31,0x32
	AREA DATASEG,DATA,READWRITE
DST DCD 0
	END