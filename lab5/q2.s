	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=SRC
	LDR R1,=DST
	LDR R2,[R0],#4
	LDR R3,[R0]
	MOV R8,#0
	MOV R10,#8
UP
	MOV R4,R2
	LSR R4,R8
	AND R4,R4,#0X0F
	MOV R5,R3
	LSR R5,R8
	AND R5,R5,#0X0F
	ADD R5,R6
	ADD R6,R4,R5
	CMP R6,#09
	BLS SKIP
	ADD R6,#06
SKIP
	AND R7,R6,#0X0F
	LSR R6,#04
	ORR R9,R7
	ROR R9,#04
	ADD R8,#04
	SUB R10,#01
	TEQ R10,#0
	BNE UP
	STR R9,[R1],#4
	STR R6,[R1]
STOP B STOP

SRC DCD 0x99999999,0x99999999
	AREA DATASEG,DATA,READWRITE

DST DCD 0
	END