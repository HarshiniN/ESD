	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler

	LDR R0,=SRC
	LDR R1,=DST
	LDR R2,[R0],#4
	LDR R3,[R0]
	CMP R2,R3
	BEQ DOWN
	
UP
	CMP R2,R3
	BHI MD
	SUB R3,R2
	B DOWN
MD	SUB R2,R3
	
DOWN 
	TEQ R2,R3
    BNE UP
    
	STR R2,[R1]





STOP B STOP
SRC DCD 1,1
	AREA DATASEG,DATA,READWRITE
DST DCD 0
	END